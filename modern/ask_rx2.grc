<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx433</value></param>
<param><key>title</key><value>ASK receiver of Keeloq remotes </value></param>
<param><key>author</key><value>Ulf Bertilsson</value></param>
<param><key>description</key><value>Modern GNU Radio Companion flowgraph validated for this repository.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>output_language</key><value>python</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RF Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>LO+freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>768</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>900,300</value></param>
<param><key>notebook</key><value>nbook,0</value></param>
<param><key>name</key><value>'RF Spectrum'</value></param>
<param><key>fftsize</key><value>768</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nbook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RF Spectrum', 'IF Spectrum']</value></param>
<param><key>grid_pos</key><value>0,0,5,5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Offset (fine)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,0,1,5</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>(1000 - -1000) / 400</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>AF</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>10,2,1,1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>step</key><value>(2 - 0) / 100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low</value></param>
<param><key>value</key><value>center-width/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>center+width/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LO</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>agc_decay</value></param>
<param><key>label</key><value>AGC</value></param>
<param><key>value</key><value>10e-6</value></param>
<param><key>choices</key><value>[100e-6, 50e-6, 10e-6]</value></param>
<param><key>labels</key><value>['Fast', 'Medium', 'Slow']</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>8,2,1,1</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[100e-6, 50e-6, 10e-6]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center</value></param>
<param><key>label</key><value>Center</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>9,0,1,2</value></param>
<param><key>start</key><value>-5000</value></param>
<param><key>stop</key><value>5000</value></param>
<param><key>step</key><value>(5000 - -5000) / 200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 25000, 2000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Offset (coarse)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100000</value></param>
<param><key>max</key><value>100000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,0,1,5</value></param>
<param><key>start</key><value>-100000</value></param>
<param><key>stop</key><value>100000</value></param>
<param><key>step</key><value>(100000 - -100000) / 1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trans</value></param>
<param><key>label</key><value>Trans</value></param>
<param><key>value</key><value>1200</value></param>
<param><key>min</key><value>100</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>10,0,1,2</value></param>
<param><key>start</key><value>100</value></param>
<param><key>stop</key><value>2000</value></param>
<param><key>step</key><value>(2000 - 100) / 100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Width</value></param>
<param><key>value</key><value>30000</value></param>
<param><key>min</key><value>1000</value></param>
<param><key>max</key><value>100000</value></param>
<param><key>num_steps</key><value>190</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,0,1,2</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>stop</key><value>100000</value></param>
<param><key>step</key><value>(100000 - 1000) / 190</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>USRP</value></param>
<param><key>value</key><value>433.72e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>9,2,1,1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>(50 - 0) / 50</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/5</value></param>
<param><key>low_cutoff_freq</key><value>low</value></param>
<param><key>high_cutoff_freq</key><value>high</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>value</key><value>freq+(offset_coarse+offset_fine)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_src</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>128</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>rf_gain</value></param>
<param><key>side</key><value>A</value></param>
<param><key>rx_ant</key><value>TX/RX</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>ant0</key><value>'TX/RX'</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>center_freq</key><value>-(offset_coarse+offset_fine)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/128</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>blks2_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>samp_rate/5</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>4000</value></param>
<param><key>audio_stop</key><value>6000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>captures/demodulated.float32</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/5</value></param>
<param><key>v_scale</key><value>20</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>2e-3</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>name</key><value>'Scope Plot'</value></param>
<param><key>srate</key><value>samp_rate/5</value></param>
<param><key>size</key><value>1024</value></param>
</block>
<connection><source_block_id>usrp_src</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_src</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blks2_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_am_demod_cf_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_am_demod_cf_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
